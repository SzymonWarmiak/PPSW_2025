# Keil uVision project UART_DEKODOWANIE.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: UART_DEKODOWANIE +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s keyboard.c led.c main.c servo.c timer.c timer_interrupts.c uart.c keyboard.h led.h servo.h TIMER.h timer_interrupts.h uart.h string.c command_decoder.c command_decoder.h string.h
